LED_FILE = "/sys/class/leds/status1\:red\:usr/brightness"
