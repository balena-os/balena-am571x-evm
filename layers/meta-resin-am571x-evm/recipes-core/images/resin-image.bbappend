IMAGE_FSTYPES_append = " resin-sdcard"
