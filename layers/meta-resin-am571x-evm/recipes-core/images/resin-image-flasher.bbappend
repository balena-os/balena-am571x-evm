IMAGE_FSTYPES_append = " resinos-img"

# Customize the flashing resinos-img
RESIN_BOOT_PARTITION_FILES_append = " \
    MLO: \
    u-boot.img: \
    "
